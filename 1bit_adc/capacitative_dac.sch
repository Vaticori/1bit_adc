v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
B 2 -2470 940 -1670 1340 {flags=graph
y1=0.020413106
y2=2.8790717
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=2.3808474e-06
x2=3.6072522e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node="
V(OUT)
V(OUTb4_BUF)
V(S2)
V(S1)
V(S0)
V(VSS)
V(SAR_SEL_0)
V(SAR_SEL_1)
V(SAR_SEL_2)
"
color="10 4 8 16 14 11 8 8 8"
dataset=-1
unitx=1
logx=0
logy=0
hcursor1_y=-0.013635606
hilight_wave=0}
B 2 -1610 120 -810 520 {flags=graph
y1=0
y2=2
ypos1=0.062189055
ypos2=2.0621891
divy=5
subdivy=1
unity=1
x1=2.3808474e-06
x2=3.6072522e-06
divx=5
subdivx=1
node="CLK
RESET
sel_wire[2]
sel_wire[1]
sel_wire[0]
OUT"
color="9 9 9 9 16"
dataset=-1
unitx=1
logx=0
logy=0
digital=1
}
B 2 -1610 -300 -810 100 {flags=graph
y1=-0.10332854
y2=1.9702715
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=2.3808474e-06
x2=3.6072522e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node="
V(OUT)
V(CLK)
V(OUT_DIGITAL)
V(RESET)
V(DONE)
"
color="10 4 17 15 17"
dataset=-1
unitx=1
logx=0
logy=0
hilight_wave=2
hcursor1_y=1.3688012}
B 2 -700 820 100 1220 {flags=graph
y1=0
y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=2.3808474e-06
x2=3.6072522e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node="

V(S1)


V(SAR_SEL_1)

"
color="10 4 8 16 14 11 8 8 8"
dataset=-1
unitx=1
logx=0
logy=0
hcursor1_y=-0.013635606
hilight_wave=0}
B 2 -700 1250 100 1650 {flags=graph
y1=0
y2=3
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=2.3808474e-06
x2=3.6072522e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node="

V(S0)
V(SAR_SEL_0)

"
color="10 4 8 16 14 11 8 8 8"
dataset=-1
unitx=1
logx=0
logy=0
hcursor1_y=-0.013635606
hilight_wave=0}
B 2 -1540 950 -740 1350 {flags=graph
y1=-0.57291626
y2=2.7270837
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=2.3808474e-06
x2=3.6072522e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node="
V(S2)
V(VREF)
V(SAR_SEL_2)
"
color="10 4 8 16 14 11 8 8 8"
dataset=-1
unitx=1
logx=0
logy=0
hcursor1_y=-0.013635606
hilight_wave=0}
B 2 1720 -620 2520 -220 {flags=graph
y1=-0.45483161
y2=3.9494947
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=2.3808474e-06
x2=3.6072522e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node="



V(SIN)
V(SH_OUT)

"
color="10 4 12 7 11 13"
dataset=-1
unitx=1
logx=0
logy=0 
hilight_wave=5
hcursor1_y=0.55666159
*V(NEGATIVE)
*V(OUT_BUFF)
*V(OUT)}
B 2 1720 220 2520 620 {flags=graph
y1=-5.4e-07
y2=6.1e-05
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=2.3808474e-06
x2=3.6072522e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node="
i(VO_CURR)
i(VO_CURR1)

"
color="12 11 15"
dataset=-1
unitx=1
logx=0
logy=0
hcursor1_y=1.1016134
hilight_wave=-1
*
*i(VO_CURR2)}
B 2 1720 -210 2520 190 {flags=graph
y1=-0.031130699
y2=2.0089318
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=2.3808474e-06
x2=3.6072522e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node="

V(VO_CUR)
V(SH_OUT)
V(C1)
V(CURR_ON)
V(CURR_MIR_SRC)
V(CURR_MIR_SRC1)
V(VMID)
V(NEGATIVE)
"
color="15 11 15 21 12 18 17 17"
dataset=-1
unitx=1
logx=0
logy=0
hcursor1_y=1.1016134
hilight_wave=5
*}
B 2 1720 670 2520 1070 {flags=graph
y1=0
y2=2
ypos1=0.1
ypos2=2.1
divy=5
subdivy=1
unity=1
x1=2.3808474e-06
x2=3.6072522e-06
divx=5
subdivx=1
node="CLK
G2
G3"
color="9 17 17"
dataset=-1
unitx=1
logx=0
logy=0
digital=1
}
B 2 1720 -1040 2520 -640 {flags=graph
y1=0
y2=2
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=2.3808474e-06
x2=3.6072522e-06
divx=5
subdivx=1
node="CLK
G2
G3"
color="9 17 17"
dataset=-1
unitx=1
logx=0
logy=0
digital=1
}
B 2 2530 220 3330 620 {flags=graph
y1=-0.0059
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=2.3808474e-06
x2=3.6072522e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node="


V(CURR_ON)
V(CURR_MIR_SRC)
V(CURR_MIR_SRC1)
V(VMID)
V(NEGATIVE)
"
color="15 11 15 21 12 18 17 17"
dataset=-1
unitx=1
logx=0
logy=0
hcursor1_y=1.1016134
hilight_wave=2
*}
B 2 -320 -880 480 -480 {flags=graph
y1=-0.33922396
y2=2.771176
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=2.3808474e-06
x2=3.6072522e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node="

V(CLK)
V(RESET)
V(sel_wire[0])
V(sel_wire[1])
V(sel_wire[2])
V(DONE)
"
color="10 12 11 8 7 21"
dataset=-1
unitx=1
logx=0
logy=0
hilight_wave=2
hcursor1_y=1.3688012


}
B 2 -1620 -730 -820 -330 {flags=graph
y1=-0.28982808
y2=2.1984919
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=2.3808474e-06
x2=3.6072522e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node="V(OUT)
V(CLK)

V(IN1_BUFF)
V(RESET_B)
V(SET_B)
V(OUT_DIGITAL)

V(DONE)"
color="4 5 6 7 8 9 10 11 12"
dataset=-1
unitx=1
logx=0
logy=0
hilight_wave=0
hcursor1_y=1.3688012
rainbow=1

V(IN1)}
B 2 -2450 120 -1650 520 {flags=graph
y1=0
y2=2
ypos1=0.062189055
ypos2=2.0621891
divy=5
subdivy=1
unity=1
x1=2.3808474e-06
x2=3.6072522e-06
divx=5
subdivx=1
node="CLK
SAR_SEL_2
SAR_SEL_1
SAR_SEL_0
sel_wire[2]
sel_wire[1]
sel_wire[0]
OUT"
color="9 9 9 9 16"
dataset=-1
unitx=1
logx=0
logy=0
digital=1
}
N -290 -100 160 -100 {lab=DAC_OUT}
N -600 -40 -530 -40 {lab=S2}
N -290 -100 -270 -80 {lab=DAC_OUT}
N -310 -80 -290 -100 {lab=DAC_OUT}
N -340 140 -290 90 {lab=S1}
N -290 90 -230 140 {lab=S1}
N -90 140 -40 90 {lab=S0}
N -40 90 20 140 {lab=S0}
N -650 140 -600 90 {lab=S2}
N -600 90 -540 140 {lab=S2}
N -300 170 -270 170 {lab=sel_wire[1]}
N -50 170 -20 170 {lab=sel_wire[0]}
N -610 170 -580 170 {lab=sel_wire[2]}
N -290 -20 -270 -20 {lab=S1}
N 1510 1030 1510 1060 {lab=CURR_ON}
N 1240 770 1350 770 {lab=NEGATIVE}
N 1450 770 1510 770 {lab=VSS}
N 1390 770 1450 770 {lab=VSS}
N 1510 800 1510 830 {lab=CURR_MIR_SRC}
N 1390 830 1510 830 {lab=CURR_MIR_SRC}
N 1390 800 1390 830 {lab=CURR_MIR_SRC}
N 1440 670 1470 670 {lab=VMID}
N 1440 670 1440 700 {lab=VMID}
N 1390 700 1440 700 {lab=VMID}
N 1390 700 1390 740 {lab=VMID}
N 1510 700 1510 740 {lab=SH_OUT}
N 1510 670 1530 670 {lab=VDD}
N 1530 640 1530 670 {lab=VDD}
N 1370 670 1390 670 {lab=VDD}
N 1370 640 1370 670 {lab=VDD}
N 1370 640 1530 640 {lab=VDD}
N 1510 1060 1530 1060 {lab=CURR_ON}
N 970 770 1090 770 {lab=SIN}
N 1150 770 1180 770 {lab=VC_IN}
N -680 -100 -290 -100 {lab=DAC_OUT}
N -680 -40 -600 -40 {lab=S2}
N -310 -20 -290 -20 {lab=S1}
N 1430 670 1440 670 {lab=VMID}
N -290 40 -290 110 {lab=S1}
N -40 -40 -40 90 {lab=S0}
N -290 -20 -290 40 {lab=S1}
N -600 -40 -600 90 {lab=S2}
N 1450 1000 1450 1030 {lab=CURR_MIR_SRC1}
N 1510 1030 1570 1030 {lab=CURR_ON}
N 1490 1060 1510 1060 {lab=CURR_ON}
N 1450 990 1450 1000 {lab=CURR_MIR_SRC1}
N 1440 1060 1450 1060 {lab=VSS}
N 1440 1060 1450 1090 {lab=VSS}
N 1570 1060 1590 1060 {lab=VSS}
N 1570 1090 1590 1060 {lab=VSS}
N 1450 1200 1570 1200 {lab=VSS}
N 1450 1090 1450 1150 {lab=VSS}
N 1320 510 1450 510 {lab=G2}
N 1320 400 1450 400 {lab=G3}
N 1480 440 1480 550 {lab=SH_OUT}
N 1550 770 1610 770 {lab=POSITIVE}
N 1450 550 1450 570 {lab=VSS}
N 1450 440 1450 460 {lab=VSS}
N 1570 1150 1570 1200 {lab=VSS}
N 1450 1150 1450 1200 {lab=VSS}
N 1570 1090 1570 1150 {lab=VSS}
N 1610 770 1660 770 {lab=POSITIVE}
N 1660 770 1660 790 {lab=POSITIVE}
N 1410 770 1410 1100 {lab=VSS}
N 1410 1200 1450 1200 {lab=VSS}
N 1410 1100 1410 1200 {lab=VSS}
N 1450 890 1450 930 {lab=#net1}
N 1570 990 1570 1030 {lab=CURR_ON}
N 1490 960 1530 960 {lab=#net2}
N 1510 930 1570 930 {lab=#net2}
N 1510 930 1510 960 {lab=#net2}
N -60 -310 10 -310 {lab=CLK}
N -60 -290 10 -290 {lab=OUT_DIGITAL}
N -60 -270 10 -270 {lab=RESET}
N 430 -90 590 10 {lab=IN1_BUFF}
N 430 -90 430 -30 {lab=IN1_BUFF}
N 590 10 740 30 {lab=IN1_BUFF}
C {opin.sym} 160 -100 0 0 {name=p19 lab=DAC_OUT}
C {code.sym} 900 -665 0 0 {name=s1 only_toplevel=false value="

.option savecurrents

.param vdd=1.8
.param clk=300n
.param settle_time=0.2u
VVDD VDD 0 DC \{vdd\}
VCLK CLK 0 PULSE(0 1.8 0   1n 1n 40n 80n)
VG2 G2   0 PULSE(0 1.8 41n 1n 1n 40n 80n)
VG3 G3 0 PULSE(0 1.8   41n 1n 1n 40n 80n)
VIN1 IN1 0 SIN(1 0.5 450k 5n)
VRESET RESET 0 PULSE(0 1.8 0 1n 1n 40n 800n)
VADD ADD   0 PULSE(0 1.8 0 1n 1n 40n 80n)

VVSS VSS 0 DC 0
VSIN SIN 0 SIN(1 0.5 450k 10n)
VVREF VREF 0 DC 1.8

*VSAR_SEL_2 SAR_SEL_2 0  PULSE(0 1.8 0 1n 1n 40n 80n)
*VSAR_SEL_1 SAR_SEL_1 0  PULSE(0 1.8 0 1n 1n 80n 160n)
*VSAR_SEL_0 SAR_SEL_0 0  PULSE(0 1.8 0 1n 1n 160n 320n)

*VCLK CLK 0 PULSE(0 1.8 0 1n 1n 20n \{settle_time\})
VSAR_SEL_2 SAR_SEL_2 0  PULSE(0 1.8 0 1n 1n \{2*settle_time\} \{4*settle_time\})
VSAR_SEL_1 SAR_SEL_1 0  PULSE(0 1.8 0 1n 1n \{4*settle_time\} \{8*settle_time\})
VSAR_SEL_0 SAR_SEL_0 0  PULSE(0 1.8 0 1n 1n \{8*settle_time\} \{16*settle_time\})


VEN EN 0 pwl(0 0  8u 0  8.1u 1.8  16u 1.8  16.1u 0  24u 0  24.1u 1.8  32u 1.8)


.tran 2n 7000n
.control

save all
echo TRAN
run
write 3bit_dac.raw all

.endc
.end
"
tclcommand="
echo $netlist_dir "
}
C {devices/code.sym} 800 -485 0 0 {name=TT_MODELS
only_toplevel=true
format="tcleval( @value )"
value="
** opencircuitdesign pdks install
.lib $::SKYWATER_MODELS/sky130.lib.spice tt
.include $::SKYWATER_STDCELLS/sky130_fd_sc_hd.spice
.include /foss/pdks/sky130A/libs.tech/xschem/sky130_stdcells/
"
spice_ignore=false}
C {launcher.sym} 1010 -405 0 0 {name=h1 
descr="Load" 
tclcommand="
echo $netlist_dir
xschem raw_read $netlist_dir/3bit_dac.raw tran
"}
C {gnd.sym} -230 200 0 0 {name=l23 lab=VSS}
C {ipin.sym} -280 310 3 0 {name=p21 lab=SAR_SEL_1}
C {vdd.sym} -340 200 2 0 {name=l25 lab=VREF}
C {sky130_fd_pr/nfet3_01v8.sym} 960 -320 1 0 {name=M7
W=1
L=0.15
body=VSS
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
VSAMPLE_CLK sample_clk 0 PULSE(0 3.3 0 1n 1n 10n 5u)}
C {ipin.sym} 960 -340 0 0 {name=p23 lab=CLK}
C {lab_pin.sym} -600 90 2 0 {name=p26 sig_type=std_logic lab=S2}
C {lab_pin.sym} -290 90 2 0 {name=p27 sig_type=std_logic lab=S1}
C {lab_pin.sym} -40 60 2 0 {name=p28 sig_type=std_logic lab=S0}
C {sky130_fd_pr/pfet3_01v8.sym} 1120 -300 0 0 {name=M8
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {gnd.sym} 1140 -330 2 0 {name=l28 lab=VSS}
C {sky130_fd_pr/nfet3_01v8.sym} -320 170 2 0 {name=M1
W=150
L=0.15
body=VSS
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} 20 200 0 0 {name=l15 lab=VSS}
C {sky130_fd_pr/pfet3_01v8.sym} 0 170 0 0 {name=M2
W=100
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {ipin.sym} -40 310 3 0 {name=p9 lab=SAR_SEL_0}
C {vdd.sym} -90 200 2 0 {name=l16 lab=VREF}
C {ipin.sym} -600 310 3 0 {name=p12 lab=SAR_SEL_2}
C {vdd.sym} -650 200 2 0 {name=l18 lab=VREF}
C {sky130_fd_pr/pfet3_01v8.sym} -250 170 0 0 {name=M4
W=100
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} -560 170 0 0 {name=M6
W=100
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} -630 170 2 0 {name=M3
W=150
L=0.15
body=VSS
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} -70 170 2 0 {name=M5
W=150
L=0.15
body=VSS
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} -540 200 0 0 {name=l1 lab=VSS}
C {sky130_fd_pr/cap_mim_m3_1.sym} -560 -70 0 0 {name=C3 model=cap_mim_m3_1 W=5 L=1 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -590 -70 0 0 {name=C5 model=cap_mim_m3_1 W=5 L=1 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -620 -70 0 0 {name=C6 model=cap_mim_m3_1 W=5 L=1 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -310 -50 0 0 {name=C7 model=cap_mim_m3_1 W=5 L=1 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -270 -50 0 0 {name=C8 model=cap_mim_m3_1 W=5 L=1 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -40 -70 0 0 {name=C9 model=cap_mim_m3_1 W=5 L=1 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -650 -70 0 0 {name=C10 model=cap_mim_m3_1 W=5 L=1 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -680 -70 0 0 {name=C11 model=cap_mim_m3_1 W=5 L=1 MF=1 spiceprefix=X}
C {sky130_stdcells/buf_1.sym} 1010 650 0 0 {name=x1 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {lab_pin.sym} 890 825 3 0 {name=p1 sig_type=std_logic lab=OUT}
C {lab_pin.sym} 1160 770 3 0 {name=p2 sig_type=std_logic lab=VC_IN}
C {launcher.sym} 1380 245 0 0 {name=h2 
descr="Load" 
tclcommand="
echo $netlist_dir
xschem raw_read $netlist_dir/3bit_dac.raw tran
"}
C {vdd.sym} 1570 810 3 0 {name=l2 lab=VDD}
C {sky130_fd_pr/res_high_po_0p35.sym} 1570 840 0 0 {name=R1
L=0.4
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {gnd.sym} 1510 1200 0 0 {name=l3 lab=VSS}
C {lab_pin.sym} 1660 790 0 0 {name=p4 sig_type=std_logic lab=POSITIVE}
C {lab_pin.sym} 1220 630 0 0 {name=p5 sig_type=std_logic lab=MINUS}
C {sky130_fd_pr/pfet_01v8.sym} 1490 670 0 0 {name=M12
W=1
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1410 670 2 0 {name=M14
W=1
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {ammeter.sym} 1450 860 0 0 {name=VO_CURR savecurrent=true spice_ignore=0}
C {lab_pin.sym} 1510 1060 3 0 {name=p6 sig_type=std_logic lab=CURR_ON}
C {opin.sym} 1370 1060 2 0 {name=p7 lab=VO_CUR}
C {gnd.sym} 1660 770 3 0 {name=l4 lab=VSS}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1040 540 1 0 {name=C1 model=cap_mim_m3_1 W=10 L=5 MF=1 spiceprefix=X}
C {lab_pin.sym} 1120 730 1 0 {name=p3 sig_type=std_logic lab=CLK}
C {vdd.sym} 1450 640 0 0 {name=l5 lab=VDD}
C {sky130_fd_pr/nfet3_01v8.sym} 1120 750 1 0 {name=M15
W=150
L=0.15
body=VSS
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} 1550 840 1 0 {name=l8 lab=VSS}
C {lab_pin.sym} 1270 770 1 0 {name=p8 sig_type=std_logic lab=NEGATIVE}
C {lab_pin.sym} 970 770 0 0 {name=p10 sig_type=std_logic lab=SIN}
C {opin.sym} 1510 720 0 0 {name=p11 lab=SH_OUT}
C {lab_pin.sym} 1390 830 0 0 {name=p13 sig_type=std_logic lab=CURR_MIR_SRC}
C {sky130_fd_pr/nfet_01v8.sym} 1470 1060 2 0 {name=M16
W=2
L=0.3
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1550 1060 0 0 {name=M9
W=2
L=0.3
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1370 770 0 0 {name=M10
W=5
L=0.3
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1530 770 2 0 {name=M11
W=1
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {ammeter.sym} 1570 900 0 0 {name=VO_CURR1 savecurrent=true spice_ignore=0}
C {sky130_fd_pr/nfet_01v8.sym} 1450 420 1 0 {name=M13
W=1
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1450 530 1 0 {name=M17
W=1
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {ipin.sym} 1320 400 0 0 {name=p15 sig_type=std_logic lab=G3}
C {ipin.sym} 1320 510 0 0 {name=p16 sig_type=std_logic lab=G2}
C {lab_pin.sym} 1420 550 0 0 {name=p17 sig_type=std_logic lab=NEGATIVE}
C {lab_pin.sym} 1420 440 0 0 {name=p18 sig_type=std_logic lab=VC_IN}
C {opin.sym} 1480 490 0 0 {name=p20 lab=SH_OUT}
C {gnd.sym} 1450 460 0 0 {name=l6 lab=VSS}
C {gnd.sym} 1450 570 0 0 {name=l9 lab=VSS}
C {lab_pin.sym} 1390 720 0 0 {name=p14 lab=VMID}
C {sky130_fd_pr/nfet_01v8.sym} 1470 960 2 0 {name=M18
W=2
L=0.3
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1550 960 0 0 {name=M19
W=2
L=0.3
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1210 770 1 0 {name=C2 model=cap_mim_m3_2 W=15 L=15 MF=1 spiceprefix=X}
C {lab_pin.sym} 1450 1010 0 0 {name=p22 sig_type=std_logic lab=CURR_MIR_SRC1}
C {ipin.sym} -60 -310 0 0 {name=p24 lab=CLK}
C {/headless/Documents/1bit_adc/three_bit_adc.sym} 160 -280 0 0 {name=x2}
C {ipin.sym} -60 -270 0 0 {name=p29 lab=RESET}
C {lab_pin.sym} 310 -310 2 0 {name=p30 sig_type=std_logic lab=sel_wire[2]}
C {lab_pin.sym} 310 -290 2 0 {name=p31 sig_type=std_logic lab=sel_wire[1]}
C {lab_pin.sym} 310 -270 2 0 {name=p32 sig_type=std_logic lab=sel_wire[0]}
C {opin.sym} 310 -250 0 0 {name=p33 lab=DONE}
C {/headless/Documents/1bit_adc/my_comparator.sym} 920 120 0 0 {}
C {iopin.sym} 1040 30 0 0 {name=p34 lab=OUT_DIGITAL
}
C {opin.sym} 1040 50 0 0 {name=p35 lab=NOUT_DIGITAL
}
C {ipin.sym} 740 70 0 0 {name=p36 lab=CLK}
C {ipin.sym} 740 90 0 0 {name=p37 lab=RESET_B}
C {ipin.sym} 740 110 0 0 {name=p38 lab=SET_B}
C {gnd.sym} 670 180 1 0 {name=l7 lab=VSS}
C {sky130_tests/n_diffamp.sym} 510 10 0 0 {name=x3}
C {iopin.sym} 430 50 2 0 {name=p39 lab=IN1}
C {vdd.sym} 490 150 1 0 {name=l10 lab=VREF}
C {sky130_fd_pr/res_high_po.sym} 490 120 0 0 {name=R9
W=1
L=1
model=res_high_po
spiceprefix=X
mult=1}
C {gnd.sym} 470 120 0 0 {name=l17 lab=VSS}
C {iopin.sym} 740 50 2 0 {name=p40 lab=DAC_OUT}
C {lab_pin.sym} -590 170 3 0 {name=p41 sig_type=std_logic lab=sel_wire[2]}
C {lab_pin.sym} -280 170 3 0 {name=p42 sig_type=std_logic lab=sel_wire[1]}
C {lab_pin.sym} -30 170 3 0 {name=p43 sig_type=std_logic lab=sel_wire[0]}
C {iopin.sym} -60 -290 2 0 {name=p25 lab=OUT_DIGITAL
}
C {iopin.sym} 740 30 3 0 {name=p44 lab=IN1_BUFF}
C {launcher.sym} -880 -755 0 0 {name=h3 
descr="Load" 
tclcommand="
echo $netlist_dir
xschem raw_read $netlist_dir/3bit_dac.raw tran
"}
